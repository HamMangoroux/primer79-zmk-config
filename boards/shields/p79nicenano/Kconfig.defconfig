## boards/shields/p79nicenano/Kconfig.defconfig
```kconfig
if SHIELD_P79NICENANO

config ZMK_KEYBOARD_NAME
    default "Primer79"

endif # SHIELD_P79NICENANO
```
